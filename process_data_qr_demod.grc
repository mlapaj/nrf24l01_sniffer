options:
  parameters:
    generate_options: qt_gui
    id: process_data
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '2475000000'
  states: {}
- name: demod_gain
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '0.1'
    stop: '5'
    value: '4'
  states: {}
- name: frq
  id: variable_qtgui_range
  parameters:
    start: 2474e6
    step: 100e3
    stop: 2478e6
    value: 2476e6
  states: {}
- name: limiter
  id: variable_qtgui_range
  parameters:
    start: '-100'
    step: '1'
    stop: '0'
    value: '-41'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: signal_freq
  id: variable
  parameters:
    value: 2476000000-128e3
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq-signal_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    comment: |-
      there will be noise like in fm demod... see:
      we basically need to get rid of this before doing quadrature demod
      https://dsp.stackexchange.com/questions/37207/avoiding-dc-spike-while-decoding-fsk-signal
    threshold: limiter
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/cod3r/Data/Hackrf/4_nrf24l01/out
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/cod3r/Data/Hackrf/4_nrf24l01/nrf24l01_capture
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: z jakiegoś powodu potrzebny DC
    cutoff_freq: 750e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Meaning the default channel of 76 uses the approximate frequency of 2476 MHz.
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/2
    fc: '0'
    fftsize: '8192'
    type: complex
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '2048'
    srate: samp_rate/2
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.01'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_binary_slicer_fb_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_file_sink_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0, '0']
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
